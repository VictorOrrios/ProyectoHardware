# Keil uVision project blink_lpc.uvproj, settings and files
target LPC_Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: blink_lpc
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RELEASE LPC2105_simulador
  c include: ../../src;../src_lpc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Comun
    ../../src/: main.c drv_leds.c drv_leds.h drv_tiempo.c drv_tiempo.h hal_gpio.h hal_tiempo.h board.h rt_fifo.h rt_fifo.c rt_evento_t.h hal_consumo.h drv_monitor.h drv_monitor.c drv_consumo.h drv_consumo.c svc_alarma.h svc_alarma.c rt_GE.h rt_GE.c hal_ext_int.h drv_botones.h drv_botones.c drv_wdt.c drv_wdt.h hal_wdt.h drv_rng.c drv_rng.h drv_sc.c drv_sc.h hal_rng.h hal_sc.h drv_uart.c drv_uart.h hal_uart.h svc_log.c svc_log.h testing.c testing.h svc_stats.h svc_stats.c
    ../../src/app/: practica_2.h practica_3.h practica_4.h practica_5.h practica_5.c practica_4.c practica_3.c practica_2.c
  group Dependientes
    ../src_lpc/: board_lpc.h hal_gpio_lpc.c hal_tiempo_lpc.c reserva_gpio_lpc2105.h hal_consumo_lpc.c hal_ext_int_lpc.c hal_wdt_lpc.c hal_sc_lpc.c hal_rng_lpc.c hal_uart_lpc.c
  group Inicio
    ../src_lpc/: Startup.s
target LPC_Testing (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: as above
  output: blink_lpc
  c flags: as above
  c define: TESTING LPC2105_simulador
  c include: ../../src;../src_lpc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
target LPC_Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: as above
  output: blink_lpc
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG WITH_DEBUG_LOGS DEBUG_STATS LPC2105_simulador
  c include: ../../src;../src_lpc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
