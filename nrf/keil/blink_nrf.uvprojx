# Keil uVision project blink_nrf.uvprojx, settings and files
target nRF_Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) IROM2(0x12000000,0x08000000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: blink_nrf +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG WITH_DEBUG_LOGS  DEBUG_STATS BOARD_PCA10056 NRF52840_XXAA CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD  __HEAP_SIZE=8192 __STACK_SIZE=8192
  c include: ../src_nrf;../../src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
  group Source Comun
    ../../src/: main.c drv_leds.c drv_leds.h drv_tiempo.c drv_tiempo.h hal_gpio.h hal_tiempo.h board.h drv_consumo.c hal_consumo.h drv_consumo.h drv_monitor.h drv_monitor.c rt_fifo.h rt_fifo.c rt_evento_t.h drv_botones.c drv_botones.h hal_ext_int.h rt_GE.c rt_GE.h svc_alarma.c svc_alarma.h drv_wdt.c svc_wdt.c svc_wdt.h drv_wdt.h hal_wdt.h drv_sc.c drv_sc.h hal_sc.h drv_rng.c drv_rng.h hal_rng.h drv_uart.c drv_uart.h hal_uart.h svc_log.c svc_log.h testing.h testing.c svc_stats.c svc_stats.h
    ../../src/app/: practica_2.c practica_3.c practica_4.c practica_5.c practica_5.h practica_4.h practica_3.h practica_2.h
  group Dependientes
    ../src_nrf/: hal_gpio_nrf.c hal_tiempo_nrf.c board_nrf52840dk.h board_nrf52840_dongle.h hal_consumo_nrf.c hal_gpio_nrf.h hal_ext_int_nrf.c hal_wdt_nrf.c hal_sc_nrf.c hal_rng_nrf.c hal_uart_nrf.c
target nRF_Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: blink_nrf +hex
  c flags: as above
  c define: RELEASE BOARD_PCA10056 NRF52840_XXAA CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD  __HEAP_SIZE=8192 __STACK_SIZE=8192
  c include: ../src_nrf;../../src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
target nRF_Testing (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: blink_nrf +hex
  c flags: as above
  c define: TESTING BOARD_PCA10056 NRF52840_XXAA CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD  __HEAP_SIZE=8192 __STACK_SIZE=8192
  c include: ../src_nrf;../../src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
software components: CMSIS:CORE 5.3.0, Device:Startup 8.44.1
